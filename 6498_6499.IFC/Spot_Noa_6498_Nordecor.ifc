Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-10-31T11:42:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 31 11:42:09 2024 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\b2defedf-d703-4b73-8e64-9896bc4b4cdf\67f3b4b9-3978-42ba-9608-f6659c329a19\ifc * Database version: 5507 * Database creation date: Thu Oct 31 11:42:07 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 31 11:42:07 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 31 11:42:07 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328201
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6498 - Branco, Spot_Noa_6498_6499_Nordecor_IFC:6498 - Branco:328201
In: Nível 1
Type - Material: Metal - Alumínio - Branco, LED, Plástico - Policarbonato - Translúcido
Type - Cotas - Altura da luminária: 40 mm; Diâmetro da luminária: 22 mm
Type - Dados - Data da atualização: 27/10/2024; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Mini spot de embutir com acabamento branco, LED 1W, 2700K 24º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 Anos; Grau de proteção: IP20; Localização: Camboriú-SC / Brasil; Modelo: 6498; Nome do tipo: 6498 - Branco; Número OmniClass: 23.80.70.11.14.14; Tipo de imagem: Imagem raster: 6498.png; Título OmniClass: Uplights; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/mini-spot-led-de-embutir-noa-1w-2-700k/
Type - Elétrico - Comentários de voltagem: 100-240V; Fator de potência - Luminária: 1; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Voltagem - Luminária: 0 V
Type - Estrutural - Peso: 0
Type - Fotométricos - Fluxo luminoso: 80 lm; Grau de abertura: 24 deg; IRC (R9): >93; IRC (RA): >90; Potência: 1 W; SDMC: <5; Temperatura de cor: 2700 K; UGR: <16
Type - Gráficos - Simbologia: Imagem raster: 6498 - 2D.png
Type - Materiais e acabamentos - Difusor: Plástico - Policarbonato - Translúcido; Luminária: Metal - Alumínio - Branco
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Spot_Noa_6498_6499_Nordecor_IFC; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes; Fonte luminosa: yes
Cotas - Área: 0.00205374 m2; Volume: 0.00000909429 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Spot_Noa_6498_6499_Nordecor_IFC: 6498 - Branco; Família e tipo: Spot_Noa_6498_6499_Nordecor_IFC: 6498 - Branco; ID de tipo: Spot_Noa_6498_6499_Nordecor_IFC: 6498 - Branco; Tipo: Spot_Noa_6498_6499_Nordecor_IFC: 6498 - Branco
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
